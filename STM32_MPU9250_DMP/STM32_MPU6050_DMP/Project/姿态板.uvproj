# Keil uVision project 姿态板.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 姿态板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\Lib\inc;..\User;..\User\eMPL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group Lib
    ../Lib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User/: main.c delay.c stm32f10x_it.c usart.c Time.c stm32_iic.c
  group eMPL
    ../User/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c my_inv_mpu.c
